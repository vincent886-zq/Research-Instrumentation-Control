# Keil uVision project usb_handwheel.uvprojx, settings and files
target EC11_USB_HANDWHEEL (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ec11_usb_handwheel +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F103xB,USE_HAL_DRIVER
  c include: .\Core\Inc;.\USB_DEVICE\App;.\USB_DEVICE\Target;.\Drivers\STM32F1xx_HAL_Driver\Inc;.\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;.\Drivers\CMSIS\Include;.\Drivers\CMSIS\Device\ST\STM32F1xx\Include;.\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;.\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ./Core/Src/: main.c handwheel.c ssd1306.c stm32f1xx_it.c system_stm32f1xx.c
    ./USB_DEVICE/App/: usb_device.c usbd_cdc_if.c
    ./USB_DEVICE/Target/: usbd_conf.c usbd_desc.c
  group HAL
    ./Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_dma.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c
  group USB Middleware
    ./Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ./Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Startup
    ./Core/Src/: startup_stm32f103x8.s
